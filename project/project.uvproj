# Keil uVision project project.uvproj, settings and files
target wdgui-stm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wdgui-stm32
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\drivers;..\stm32lib;..\stm32lib\startup;..\system;..\user;..\windgui;..\drivers\SD_FS;..\drivers\SD_FS\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group stm32lib
    ../stm32lib/: system_stm32f10x.c stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c core_cm3.c
    ../stm32lib/startup/: startup_stm32f10x_hd.s
  group drivers
    ../drivers/: spi_flash.c spi.c delay.c usart.c key.c dac.c lcd.c fonts.c led.c
    ../drivers/SD_FS/: rtc.c sdcard.c timestamp.c
    ../drivers/SD_FS/FatFs/: diskio.c ff.c
  group user
    ../user/: main.c lavasim.c boshi.c lvm.c prtscr.c
  group system
    ../system/: stm32f10x_it.c stm32f10x_conf.h
